# Keil uVision project project_for_keil_4.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: dummy +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB, USE_FULL_ASSERT, USE_STDPERIPH_DRIVER, STM32F10X_MD, HSE_VALUE=8000000
  c misc: --c99
  c include: .\src\cmsis;.\src;.\src\mcu_support_package\inc;.\src\spl\inc;.\src\spl
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\stack_protection.sct
  group main
    ./src/main/: main.c
  group mcu_support_package
    ./src/mcu_support_package/: system_stm32f10x.c
    ./src/mcu_support_package/arm/: startup_stm32f103xb.s
  group spl
    ./src/spl/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
